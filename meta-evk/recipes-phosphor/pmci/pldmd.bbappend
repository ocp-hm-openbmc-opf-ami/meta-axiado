CXXFLAGS += "-Wno-error=conversion -Wno-error=useless-cast"
