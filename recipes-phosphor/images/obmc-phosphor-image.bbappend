OBMC_IMAGE_EXTRA_INSTALL:append = " boot-state \
                                    u-boot-axiado \
                                    "
