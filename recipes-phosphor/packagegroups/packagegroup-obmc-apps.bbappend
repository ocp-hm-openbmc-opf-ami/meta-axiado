RDEPENDS:${PN}-network += " ax-net iptables iproute2 net-tools"
