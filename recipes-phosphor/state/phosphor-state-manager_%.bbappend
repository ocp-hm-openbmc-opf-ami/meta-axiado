FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Trigger-ax3000-fw-update-s-for-hard-reset-via-IPMI.patch"
